# Autodesk Inventor assembly: 21.1756_1 DOOR CATCH GRAY
## iProperties
Created: 2007-03
Part Number: 21.1756_1 DOOR CATCH GRAY
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
